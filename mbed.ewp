# IAR project mbed.ewp, settings and files
configuration mbed (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __MBED__=1; DEVICE_I2CSLAVE=1; TARGET_LIKE_MBED; TARGET_Freescale; DEVICE_PORTINOUT=1; DEVICE_PORTIN=1; DEVICE_RTC=1; TOOLCHAIN_object; __CMSIS_RTOS; TARGET_KL46Z; TARGET_KLXX; TARGET_CORTEX_M; TARGET_M0P; DEVICE_ANALOGOUT=1; MBED_BUILD_TIMESTAMP=1472606976.87; TARGET_UVISOR_UNSUPPORTED; TOOLCHAIN_IAR; DEVICE_INTERRUPTIN=1; DEVICE_I2C=1; DEVICE_PORTOUT=1; __CORTEX_M0PLUS; DEVICE_STDIO_MESSAGES=1; DEVICE_PWMOUT=1; TARGET_FF_ARDUINO; TARGET_RELEASE; ARM_MATH_CM0PLUS; __MBED_CMSIS_RTOS_CM; DEVICE_SLEEP=1; DEVICE_SPI=1; DEVICE_ERROR_RED=1; DEVICE_SPISLAVE=1; DEVICE_ANALOGIN=1; DEVICE_SERIAL=1; DEVICE_SEMIHOST=1; TARGET_LIKE_CORTEX_M0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: --guard_calls; --preinclude=mbed_config.h; --preinclude=mbed_config.h
  ICCARM.CCIncludePath2: .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: MBED_12.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Source_Files
    ./: AnalogIn.h AnalogOut.h Base.h BusIn.h BusInOut.h BusOut.h CAN.h can_helper.h device.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h FileHandle.h FileLike.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h LocalFileSystem.h mbed.h mbed_interface.h PeripheralNames.h PinNames.h platform.h PortIn.h PortInOut.h PortNames.h PortOut.h PwmOut.h rpc.h rtc_time.h Serial.h SerialHalfDuplex.h SPI.h SPIHalfDuplex.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h us_ticker_api.h wait_api.h
